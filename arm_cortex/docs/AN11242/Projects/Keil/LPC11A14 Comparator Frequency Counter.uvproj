# Keil uVision project LPC11A14 Comparator Frequency Counter.uvproj, settings and files
target LPC11A14 Comparator Frequency Counter (ARM-ADS)
  device: LPC11A14/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPC11A14 Comparator Frequency Counter
  c flags: Optim=1
  c include: ..\..\Source\DeviceSupport;..\..\Source\DeviceSupport\CMSIS;..\..\Source\LCD;..\..\Source\UART
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Application
    ../../Source/Application/: main.c
    ../../Source/: Read-me.txt
  group DeviceSupport
    ../../Source/DeviceSupport/: system_LPC11Axx.c startup_LPC11Axx.s
  group LCD
    ../../Source/LCD/: drv_hd44780.c drv_hd44780_l.c
  group UART
    ../../Source/UART/: uart.c retarget_Keil.c
