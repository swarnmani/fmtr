<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LPC11A14 Comparator Frequency Counter.ewp</path>
  </project>
  <batchBuild/>
</workspace>


