# IAR project LPC11A14 Comparator Frequency Counter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11A14 NXP LPC11A14
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pe161, Pa082
  ICCARM.CCIncludePath2: ..\..\Source\DeviceSupport; ..\..\Source\DeviceSupport/CMSIS; ..\..\Source\LCD; ..\..\Source\UART
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPC11A14 Comparator Frequency Counter.srec
  ILINK.IlinkOutputFile: LPC11A14 Comparator Frequency Counter.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../Source/: Read-me.txt
  group Application
    ../../Source/Application/: main.c
  group DeviceSupport
    ../../Source/DeviceSupport/: cstartup_M.s system_LPC11Axx.c
  group LCD
    ../../Source/LCD/: drv_hd44780.c drv_hd44780_l.c
  group UART
    ../../Source/UART/: retarget_IAR.c uart.c
