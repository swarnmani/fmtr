# Keil uVision project CoosDemo.uvproj, settings and files
target CoosDemo (ARM-ADS)
  device: LPC1114x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: CoosDemo
  c flags: Optim=1
  c include: ..\LPC111x_Lib\include;..\CoOS\kernel;..\CoOS\portable;..\CMSIS;..\CMSIS\cmsis_core;..\CMSIS\cmsis_lpc11xx
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group APP
    ../App/: main.c
  group CMSIS
    ../CMSIS/cmsis_core/: core_cm0.c
    ../CMSIS/cmsis_lpc11xx/: system_LPC11xx.c
    ../CMSIS/cmsis_lpc11xx/startup/: startup_LPC11xx.s
  group LPC11xx_Lib
    ../LPC111x_Lib/source/: lpc11xx_adc.c lpc11xx_gpio.c lpc11xx_i2c.c lpc11xx_iocon.c lpc11xx_pmu.c lpc11xx_ssp.c lpc11xx_syscon.c lpc11xx_tmr.c lpc11xx_uart.c lpc11xx_wdt.c
  group Coos
    ../CoOS/kernel/: core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c queue.c sem.c serviceReq.c task.c time.c utility.c timer.c
    ../CoOS/portable/Keil/: port.c
    ../CoOS/portable/: arch.c
  group Documentation
    ./: readme.txt
